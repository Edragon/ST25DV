# IAR project Profiles.ewp, settings and files
configuration Server (ARM)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc; ..\..\..\Bluetooth LE\Profile_Framework\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Profiles.hex
  ILINK.IlinkOutputFile: Profiles.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group blestack/hci
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/: hci.c
  group blestack/hci/controller
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
  group blestack/includes
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/includes/: ble_status.h bluenrg_aci.h bluenrg_aci_const.h bluenrg_gap_aci.h bluenrg_gatt_aci.h bluenrg_hal_aci.h bluenrg_l2cap_aci.h bluenrg_updater_aci.h bluenrg_utils.h clock.h compiler.h gap.h gatt_server.h gp_timer.h hal.h hal_types.h hci.h hci_const.h link_layer.h list.h osal.h sm.h
  group blestack/utils
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c
    ../../../Bluetooth LE/Profile_Framework/utils/: timer.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group platform/STM32L1XX
    ../../../platform/STM32L1XX/: clock.c hal.c hal_profiles.c osal.c
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_Io.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c
  group Profile_Test
    ../../../Bluetooth LE/Profile_Framework/test/: profiles_test_application.c
  group profiles/ble_profile
    ../../../Bluetooth LE/Profile_Framework/profiles/ble_profile/: profile.c
  group profiles/HID Device
    ../../../Bluetooth LE/Profile_Framework/profiles/hid_device/: hid_device.c hid_device_sm_services.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_tim.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../platform/STM32L1XX/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: hw_config.c main.c stm32l1xx_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
